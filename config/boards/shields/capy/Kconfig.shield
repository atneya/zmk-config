## config/boards/shields/capy/Kconfig.shield
```kconfig
# Copyright (c) 2022 Atneya Nair
# SPDX-License-Identifier: MIT

config SHIELD_CAPY
       def_bool $(shields_list_contains,capy)
```
